options:
  parameters:
    generate_options: qt_gui
    id: test_iq
    output_language: python
    title: Testing IQ
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 20e6 / 4
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/saltchicken/Desktop/experimental_pyuhd/file3.bin
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 105e6
    fftsize: '2048'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
